Commit message: base model

File: urdf/robot.urdf.xacro (robot description, xacro)
@@ -1,4 +1,4 @@
 <?xml version="1.0"?>
 <robot xmlns:xacro="http://www.ros.org/wiki/xacro"  name="diffbot_tut">
-    <link name="base_link"/>
+    <xacro:include filename="robot_core.xacro" />
 </robot>
